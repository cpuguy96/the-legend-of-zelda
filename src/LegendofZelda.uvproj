# Keil uVision project LegendofZelda.uvproj, settings and files
target LegendofZelda (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: LegendofZelda
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s random.s DAC.c Timer0.c Timer1.c Sound.c LCD.s Print.s ST7735.c LegendofZelda.c Tiles.c Map.c SysTickInts.c Grid.c Sprites.c ADC.c Items.c Sentence.c Sprite_Images.c Sentence_Images.c
  group ObjectCode
    ./: texas.o
